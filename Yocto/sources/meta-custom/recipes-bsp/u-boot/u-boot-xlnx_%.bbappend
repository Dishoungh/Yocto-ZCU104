FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

# Custom U-Boot Diffconfig
SRC_URI += "file://u-boot.cfg"